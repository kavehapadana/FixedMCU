# Keil uVision project Fixed_MCU.uvprojx, settings and files
target Fixed_MCU (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(100000000) ELITTLE
  output: Fixed_MCU
  c flags: Optim=1
  c include: ..\Drivers\include;..\RTE\Device\LPC1768;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group User
    ../User/: main.c Messaging.c PID.c User_GPIO.c User_Uart.c AC_MotorDriverMsg.c Messaging_PC.c serial.cpp
  group Drivers
    ../Drivers/source/: lpc17xx_clkpwr.c lpc17xx_exti.c lpc17xx_gpio.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_libcfg_default.c
  group ::Device
    RTE/Device/LPC1768/: startup_LPC17xx.s system_LPC17xx.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
